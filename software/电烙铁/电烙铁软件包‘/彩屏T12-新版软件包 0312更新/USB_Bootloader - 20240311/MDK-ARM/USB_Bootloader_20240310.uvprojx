# Keil uVision project USB_Bootloader_20240310.uvprojx, settings and files
target USB_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.0.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_Bootloader +hex
  AfterMake: "D:\T12-STATION\New App\USB_CDC_MSC - 20240229\MDK-ARM\rename.bat"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/user_lib;../Drivers/ui_lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
software components: CMSIS:CORE 5.5.0
